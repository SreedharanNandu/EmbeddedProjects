# Keil uVision project Radio.uvprojx, settings and files
target Si4735_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Radio +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: ..\App;..\Common;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group App
    ./: startup_LPC11xx.s
    ../App/: main.c System.h APP_Si.c App_Si_Intf.c APP_Si_Fm_Table.c APP_Si_Am_Table.c lcd.c lcd_Table.c APP_Rds.c App_Btn.c rotary.c rotary1.c SH1106.c fonts.c photo.c
  group Driver
    ../Driver/: clkconfig.c core_cm0.c gpio.c system_LPC11xx.c timer16.c clkconfig.h core_cm0.h gpio.h LPC11xx.h system_LPC11xx.h timer16.h i2c.c EEPROM.c
  group Common
    ../Common/: type.h
software components: CMSIS:CORE 5.3.0
