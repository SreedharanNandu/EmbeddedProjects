# IAR project CAN.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 256
  General.GFarHeapSize: 4096
  General.GeneralDeviceSelect: 78F1827_48 78K0R - uPD78F1827_48
  ICC78000.CCIncludePath2: APP; EAL; HAL; SCHEDULER
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 1
  ICC78000.CCOptStrategy: 0
  A78000.ADefines: __NEAR_MODEL__; __NEAR_DATA_MODEL__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f1827_48.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC78000.CCDefines: NDEBUG
  ICC78000.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    APP/: App_Can.c App_Can.h APP_Serial.c APP_Serial.h
  group EAL
    EAL/: EAL_CAN.c EAL_CAN.h INTF_UTL.c INTF_UTL.h INTF_VTMR.c INTF_VTMR_API.h INTF_VTMR_Config.h
  group HAL
    HAL/: CG_timer.h cstartup.s26 HAL_ADC.c HAL_ADC_API.h HAL_CAN.c HAL_CAN_API.h HAL_CAN_Config.h HAL_Init.c HAL_Init.h HAL_Interrupt_API.h HAL_Interrupts.c HAL_PortPin.c HAL_PortPin_API.h HAL_SYSCLK.c HAL_SYSCLK_API.h HAL_Timer.c HAL_Timer_API.h HAL_USART.c HAL_USART.h HAL_WDT.c HAL_WDT_API.h io78f1827_48.h io78f1827_48_ext.h
  group MOS
    SCHEDULER/: MOS.c MOS.h MOS_cfg.h system_def.h
