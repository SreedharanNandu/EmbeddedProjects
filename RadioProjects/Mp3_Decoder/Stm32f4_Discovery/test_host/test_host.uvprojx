# Keil uVision project test_host.uvprojx, settings and files
target test_host (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_host +hex
  group App
    ../: Audio.c main.c stm32f4xx_it.c syscalls.c system_stm32f4xx.c usb_bsp.c usbh_usr.c
    ../lib/: startup_stm32f4xx.s
  group fat_fs
    ../lib/fat_fs/src/: fattime.c ff.c
    ../lib/fat_fs/src/option/: ccsbcs.c
  group helix
    ../lib/helix/: mp3dec.c mp3tabs.c
    ../lib/helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
  group StdPeriph
    ../lib/StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USB_Host
    ../lib/USB_Host/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../lib/USB_Host/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../lib/USB_OTG/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usb_otg.c
