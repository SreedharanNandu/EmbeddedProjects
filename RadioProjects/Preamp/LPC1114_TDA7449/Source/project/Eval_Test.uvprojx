# Keil uVision project Eval_Test.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Eval_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\project;..\source\App;..\source\Common;..\source\Driver;..\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ../source/App/: App_Audio.c App_Buttons.c App_I2c_Intf.c App_Led.c Cal_Const.c
    ../source/Common/: main.c retarget.c
    ../source/Driver/: clkconfig.c gpio.c i2c.c system_LPC11xx.c timer16.c timer32.c uart.c startup_LPC11xx.s adc.c
software components: CMSIS:CORE 6.2.0
