# Keil uVision project FM.uvprojx, settings and files
target FM (6100001::V6.10.1::.\ARMCLANG)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\include;..\project;..\source\App;..\source\Common;..\source\Driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group App
    ../source/App/: App_Buttons.c App_I2c_Intf.c App_Led.c App_Rotary.c App_Eeprom.c APP_Si.c Cal_Const.c
  group Common
    ../source/Common/: retarget.c main.c type_sys.h
    ../source/Driver/: startup_LPC11xx.s
  group Driver
    ../source/Driver/: clkconfig.c gpio.c i2c.c system_LPC11xx.c timer16.c uart.c clkconfig.h core_cm0.h gpio.h i2c.h LPC11xx.h system_LPC11xx.h timer16.h timer32.h uart.h
  group Include
    ../include/: App_Buttons.h App_I2c_Intf.h App_Led.h App_Rotary.h type_sys.h APP_Si.h
software components: CMSIS:CORE 5.1.2
