# Keil uVision project Radio_Project..uvprojx, settings and files
target Radio_TEA5768 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Radio_Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: ..\App;..\Common;..\Driver;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ../App/: Buttons.c Eeprom.c Led.c main.c Sensor.c Serial.c Timer.c Radio.c Rotary.c
  group Driver
    ../Driver/: clkconfig.c core_cm0.c gpio.c system_LPC11xx.c timer16.c uart.c clkconfig.h core_cm0.h gpio.h LPC11xx.h system_LPC11xx.h timer16.h timer32.h uart.h startup_LPC11xx.s i2c.c
  group Common
    ../Common/: retarget.c type.h
software components: CMSIS:CORE 5.1.2
