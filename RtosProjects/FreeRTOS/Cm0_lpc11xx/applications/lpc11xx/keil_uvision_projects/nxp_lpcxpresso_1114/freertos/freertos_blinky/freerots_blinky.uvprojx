# Keil uVision project freerots_blinky.uvprojx, settings and files
target iflash_nxp_lpcxpresso_1114 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: freertos_blinky_iflash_nxp_lpcxpresso_1114 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_1114;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11xx;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\software\freertos\freertoslpc;..\..\..\..\examples\freertos\freertos_blinky;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_1114\keil_output
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_1124;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11xx;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_1114\keil_output
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group example
    ../../../../startup_code/: sysinit.c
    ../../../../examples/freertos/startup_code/: keil_freertos_startup_lpc11xx.s
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_1114/keil_output/: board_nxp_lpcxpresso_1114.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/keil_output/: chip_11xx_lib.lib
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port_m0.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
software components: CMSIS:CORE 5.6.0
