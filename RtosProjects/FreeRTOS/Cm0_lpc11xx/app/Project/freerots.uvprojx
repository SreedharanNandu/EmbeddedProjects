# Keil uVision project freerots.uvprojx, settings and files
target freertos (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: freertos +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: CORE_M0
  c include: ..\Src\freertos;..\Src\periph;..\..\bsw\include;..\..\bsw\common;..\..\bsw\CMSIS\Include;..\..\bsw\Board_Lib;..\Src\freertos\include;..\Src;..\..\bsw\Board_Common;..\..\bsw\include;..\Src\freertos\portable;..\Src\freertos\portable\RVDS\ARM_CM0;..\..\bsw\include
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\Src\freertos;..\Src\periph;..\..\bsw\Board_Common;..\..\bsw\CMSIS\Include;..\..\bsw\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group example
    ../Src/: sysinit.c keil_freertos_startup_lpc11xx.s main.c
  group lib
    ../../bsw/Chip_Lib/Project/keil_output/: chip.lib
    ../../bsw/Board_Lib/Project/keil_output/: board.lib
  group FreeRTOS
    ../Src/freertos/: croutine.c FreeRTOSCommonHooks.c list.c queue.c tasks.c timers.c
    ../Src/freertos/portable/RVDS/ARM_CM0/: port_m0.c
    ../Src/freertos/portable/MemMang/: heap_3.c
software components: CMSIS:CORE 5.6.0
