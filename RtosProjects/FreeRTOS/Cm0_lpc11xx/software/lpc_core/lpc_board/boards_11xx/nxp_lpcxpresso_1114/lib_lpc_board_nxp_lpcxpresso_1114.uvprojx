# Keil uVision project lib_lpc_board_nxp_lpcxpresso_1114.uvprojx, settings and files
target nxp_lpcxpresso_1114 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: board_nxp_lpcxpresso_1114 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_11xx;..\..\..\lpc_chip\chip_common;..\..\..\lpc_chip\chip_11xx\config_11xx;..\nxp_lpcxpresso_1114;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group board_nxp_lpcxpresso_1114
    ./: board_sysinit.c board.c
software components: CMSIS:CORE 5.6.0
